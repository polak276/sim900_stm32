# Keil uVision project tft_sd_sim900.uvproj, settings and files
target projekt (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: tft_sd_sim900 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F30X_MD
  c include: .\pliki1;.\STM32F30x_StdPeriph_Driver\src;.\STM32F30x_StdPeriph_Driver\inc;..\projekt_tft_sd_sim900;.\pliki1\FATFs\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group User Code
    ./pliki1/: stm32f30x_conf.h stm32f30x_it.c main.c stm32f30x_it.h colors.h delay_1.c delay_1.h ssd1963.c ssd1963.h drawing1.c sd1.c sd1.h drawing1.h config.c config.h uart.c uart.h
  group Peryferia
    ./STM32F30x_StdPeriph_Driver/src/: stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_rcc.c stm32f30x_spi.c stm32f30x_usart.c
  group CMSIS
    ./CMSIS/Include/: core_cm4.h
    ./CMSIS/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
    ./CMSIS/Device/ST/STM32F30x/Include/: stm32f30x.h system_stm32f30x.h
  group RVMDK
    ./: startup_stm32f30x.s
  group SD
    ./pliki1/FATFs/: sd_stm32.c
    ./pliki1/FATFs/src/: diskio.h ff.c ff.h ffconf.h integer.h
